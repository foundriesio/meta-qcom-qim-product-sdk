CORE_IMAGE_BASE_INSTALL += "packagegroup-qcom-qim-product"
