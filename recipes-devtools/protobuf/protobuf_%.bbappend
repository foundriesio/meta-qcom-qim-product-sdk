EXTRA_OECONF:append:qcom = " --with-pic"
